require yagl.inc

SRC_URI += "git://review.tizen.org/platform/adaptation/emulator/emulator-yagl;tag=${SRCREV};nobranch=1"

SRCREV = "1de389884a211e241f3aa9b5bd0188cb91f5c0e1"

S = "${WORKDIR}/git"
