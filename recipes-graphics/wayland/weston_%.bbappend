# Add specific weston.sh profile for emulator
FILESEXTRAPATHS_prepend_emulator := "${THISDIR}/${PN}:"
