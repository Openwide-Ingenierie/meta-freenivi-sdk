CFLAGS += "-latomic_ops"
