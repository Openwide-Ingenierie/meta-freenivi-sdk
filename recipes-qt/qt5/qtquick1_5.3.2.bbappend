INSANE_SKIP_${PN}-examples-dev = "libdir"
INSANE_SKIP_${PN}-examples-dbg = "libdir"
