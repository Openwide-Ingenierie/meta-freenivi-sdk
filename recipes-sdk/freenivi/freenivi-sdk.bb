DESCRIPTION = "Freenivi packaged SDK."

inherit freenivi-dev-image freenivi-sdk